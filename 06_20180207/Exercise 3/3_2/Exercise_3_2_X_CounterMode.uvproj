# Keil uVision project Exercise_3_2_X_CounterMode.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Exercise_3_2_X_CounterMode
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Exercise_3_2_X_CounterMode.c
    ../../../TM4C_Common/: driverlib.lib PLL.c PLL.h startup.s tm4c123gh6pm.h
